# Keil uVision project CW32_new_pro.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: CW32F003F4 WHXY
  pack: WHXY.CW32F003_DFP.1.0.4
  cpu: IRAM(0x20000000,0x00C00) IROM(0x00000000,0x05000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: CW32_new_pro
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: .\Libraries\inc;.\System\ADC;.\System\BTIM;.\System\UART;.\System\FLASH;.\Hardware\Nixie;.\Hardware\Key;.\Component\Filter;.\Component\Calibration;.\Component\Menu
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x5000
  memory RVCT9: RAM 0x20000000 size 0xc00
  group USER
    ./: main.c startup_cw32f003.s interrupts_cw32f003.c
  group cw32_lib
    ./Libraries/src/: cw32f003_adc.c cw32f003_atim.c cw32f003_awt.c cw32f003_btim.c cw32f003_crc.c cw32f003_debug.c cw32f003_digitalsign.c cw32f003_flash.c cw32f003_gpio.c cw32f003_gtim.c cw32f003_i2c.c cw32f003_iwdt.c cw32f003_lvd.c cw32f003_pwr.c cw32f003_ram.c cw32f003_rcc.c cw32f003_spi.c cw32f003_systick.c cw32f003_uart.c cw32f003_vc.c cw32f003_wwdt.c system_cw32f003.c
  group Hardware
    ./Hardware/Nixie/: Nixie.c
    ./Hardware/Key/: KeyStateMachine.c
  group Component
    ./Component/Filter/: AverageFilter.c
    ./Component/Calibration/: Calibration.c
    ./Component/Menu/: Menu.c
  group System
    ./System/FLASH/: FLASH.c
    ./System/ADC/: ADC.c
    ./System/BTIM/: BTIM.c
    ./System/UART/: UART.c
software components: CMSIS:CORE 5.4.0
