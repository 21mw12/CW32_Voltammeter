# Keil uVision project project8.uvprojx, settings and files
target project8 (ARM-ADS)
  device: CW32F003F4 WHXY
  pack: WHXY.CW32F003_DFP.1.0.4
  cpu: CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: 均值滤波
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: .\Driver;.\Hardware;.\User
  library: MicroLIB
  group Driver
    ./Driver/: cw32f003_adc.c cw32f003_atim.c cw32f003_awt.c cw32f003_btim.c cw32f003_crc.c cw32f003_debug.c cw32f003_digitalsign.c cw32f003_flash.c cw32f003_gpio.c cw32f003_gtim.c cw32f003_i2c.c cw32f003_iwdt.c cw32f003_lvd.c cw32f003_pwr.c cw32f003_ram.c cw32f003_rcc.c cw32f003_spi.c cw32f003_systick.c cw32f003_uart.c cw32f003_vc.c cw32f003_wwdt.c system_cw32f003.c startup_cw32f003.s
  group Hardware
    ./Hardware/: BTIM1.c Seg_Dis.c ADC.c
    ./User/: flash.c
  group User
    ./User/: interrupts_cw32f003.c main.c log.c
software components: CMSIS:CORE 5.6.0
