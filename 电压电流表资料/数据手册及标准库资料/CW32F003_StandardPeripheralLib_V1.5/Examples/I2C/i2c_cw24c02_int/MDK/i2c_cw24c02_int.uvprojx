# Keil uVision project i2c_cw24c02_int.uvprojx, settings and files
target i2c_cw24c02_int (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: CW32F003F4 PS
  pack: PS.CW32F003_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00C00) IROM(0x00000000,0x05000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: i2c_cw24c02_int +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 wLevel=2
  c include: ..\..\..\..\IdeSupport\MDK;..\..\..\..\Libraries\inc;..\USER\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x5000
  memory RVCT9: RAM 0x20000000 size 0xc00
  link misc: --keep=*Handler
  group User
    ../USER/src/: main.c interrupts_cw32f003.c
  group Driver
    ../../../../Libraries/src/: cw32f003_i2c.c cw32f003_gpio.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0
