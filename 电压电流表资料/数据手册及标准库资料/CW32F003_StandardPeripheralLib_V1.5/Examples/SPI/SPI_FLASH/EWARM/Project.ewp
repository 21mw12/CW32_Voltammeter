# IAR project Project.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: CW32F003F4 PS CW32F003F4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\USER\inc; ..\..\..\..\Libraries\inc; ..\..\..\..\IdeSupport\EWARM; ..\..\..\..\Utilities
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Template.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\CW\CW32F003F4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Driver
    ../../../../Libraries/src/: cw32f003_gpio.c cw32f003_rcc.c cw32f003_spi.c cw32f003_uart.c
  group Startup
    ../../../../IdeSupport/EWARM/: startup_cw32f003.s
    ../../../../Libraries/src/: system_cw32f003.c
  group User
    ../USER/src/: cw32_eval_spi_flash.c interrupts_cw32f003.c main.c
    ../../../../Utilities/: cw32f003e4p7_startkit.c
