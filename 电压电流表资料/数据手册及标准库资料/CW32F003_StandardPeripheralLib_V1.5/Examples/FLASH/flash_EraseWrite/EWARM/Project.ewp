# IAR project Project.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: CW32F003F4 PS CW32F003F4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\USER\inc; ..\..\..\..\Libraries\inc; ..\..\..\..\IdeSupport\EWARM
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration debug (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __DEBUG
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: HC32F030.icf
  group Driver
    ../../../../Libraries/src/: cw32f003_flash.c cw32f003_gpio.c cw32f003_rcc.c
  group Startup
    ../../../../IdeSupport/EWARM/: startup_cw32f003.s
    ../../../../Libraries/src/: system_cw32f003.c
  group User
    ../USER/src/: interrupts_cw32f003.c main.c
