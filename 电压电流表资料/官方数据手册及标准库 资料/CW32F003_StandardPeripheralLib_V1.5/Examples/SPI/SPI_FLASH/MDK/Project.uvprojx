# Keil uVision project Project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: CW32F003F4 PS
  pack: PS.CW32F003_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00C00) IROM(0x00000000,0x05000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 wLevel=2
  c include: ..\..\..\..\IdeSupport\MDK;..\..\..\..\Libraries\inc;..\USER\inc;..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x5000
  memory RVCT9: RAM 0x20000000 size 0xc00
  link misc: --keep=*Handler
  group Startup
    ../../../../IdeSupport/MDK/: startup_cw32f003.s
    ../../../../Libraries/src/: system_cw32f003.c
  group User
    ../USER/src/: main.c interrupts_cw32f003.c cw32_eval_spi_flash.c
    ../../../../Utilities/: cw32f003e4p7_startkit.c
  group Driver
    ../../../../Libraries/src/: cw32f003_gpio.c cw32f003_rcc.c cw32f003_spi.c cw32f003_uart.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.4.0
