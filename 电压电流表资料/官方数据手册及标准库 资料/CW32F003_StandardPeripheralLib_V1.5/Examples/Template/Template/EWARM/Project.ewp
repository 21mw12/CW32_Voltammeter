# IAR project Project.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Template.hex
  ILINK.IlinkOutputFile: Project.out
  group Startup
    ../../../../IdeSupport/EWARM/: startup_cw32f003.s
    ../../../../Libraries/src/: system_cw32f003.c
  group User
    ../USER/src/: interrupts_cw32f003.c main.c
